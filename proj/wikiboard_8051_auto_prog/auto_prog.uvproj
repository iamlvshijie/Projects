# Keil uVision project auto_prog.uvproj, settings and files
target 8051 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: auto_prog +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: auto_prog.c
