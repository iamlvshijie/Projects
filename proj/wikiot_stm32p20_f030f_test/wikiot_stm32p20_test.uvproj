# Keil uVision project wikiot_stm32p20_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: wikiot_stm32p20_test
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: startup_stm32f030.s
  group APP
    ./: main.c
  group BSP
    ../../brd/wikiot_stm32p20_f030f/: bsp.c
