# Keil uVision project yd_stm32f051c8_test.uvproj, settings and files
target vs10x3_test (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: wikiot_stm32p20_test
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: startup_stm32f0xx.s
  group APP
    ./: app.c
  group Driver
    ../../driver/: led.c tick.c serial.c
  group BSP
    ../../brd/yd_stm32f051c8/: bsp.c
  group HAL
    ../../hal/stm32f0/: hal_io.c hal_core.c hal_systick.c hal_uart.c hal_spi.c hal_int.c
  group StdLib
    ../../lib/stm32f0_std_lib/1.0/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_iwdg.c stm32f0xx_dma.c stm32f0xx_dbgmcu.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_flash.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_wwdg.c
    ../../lib/stm32f0_std_lib/1.0/: system_stm32f0xx.c
  group Doc
    ./: Readme.txt
target led_test (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: yd_stm32051c8_test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\..\driver;..\..\hal\stm32f0;..\..\lib\stm32f0_std_lib\1.0;..\..\lib\stm32f0_std_lib\1.0\inc;..\yd-stm32f051c8_test;..\..\brd\yd_stm32f051c8;..\..\lib\stm32f0_std_lib\1.0\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
